options:
  parameters:
    author: Piotr Krysik
    category: Custom
    description: 'Interactive monitor of a single C0 channel with analysis performed by Wireshark (command to run wireshark: sudo wireshark -k -f udp -Y gsmtap -i lo)'
    generate_options: qt_gui
    id: grgsm_livemon
    output_language: python
    title: Gr-gsm Livemon
  states: {}

blocks:
- name: fc_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '100'
    start: 800e6
    step: 2e5
    stop: 1990e6
    value: fc
  states: {}
- name: lna_slider
  id: variable_qtgui_range
  parameters:
    comment: HackRF LNA. 0-40 dB, 8 dB steps.
    label: LNA gain (IF)
    min_len: '100'
    start: '0'
    step: '8'
    stop: '40'
    value: lna_gain
    widget: counter
  states: {}
- name: vga_slider
  id: variable_qtgui_range
  parameters:
    comment: HackRF VGA. 0-62 dB, 2 dB steps.
    label: VGA gain (BB)
    min_len: '100'
    start: '0'
    step: '2'
    stop: '62'
    value: vga_gain
    widget: counter
  states: {}
- name: ppm_slider
  id: variable_qtgui_range
  parameters:
    label: PPM Offset
    min_len: '100'
    start: '-150'
    step: '0.1'
    stop: '150'
    value: ppm
    widget: counter
  states: {}
- name: args
  id: parameter
  parameters:
    label: Device Arguments
    type: str
    value: '""'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2*pi*shiftoff/samp_rate'
  states: {}
- name: collector
  id: parameter
  parameters:
    label: IP or DNS name of collector point
    type: str
    value: '"localhost"'
  states: {}
- name: collectorport
  id: parameter
  parameters:
    label: UDP port number of collector
    type: str
    value: '4730'
  states: {}
- name: fc
  id: parameter
  parameters:
    label: GSM channel's central frequency
    short_id: f
    type: eng_float
    value: '934200000'
  states: {}
- name: lna_gain
  id: parameter
  parameters:
    comment: HackRF LNA/IF stage. 0-40 dB, 8 dB steps. Safe to adjust freely.
    label: LNA gain (IF)
    short_id: g
    type: eng_float
    value: '16'
  states: {}
- name: vga_gain
  id: parameter
  parameters:
    comment: HackRF VGA/baseband stage. 0-62 dB, 2 dB steps. Safe to adjust freely.
    label: VGA gain (BB)
    short_id: v
    type: eng_float
    value: '20'
  states: {}
- name: amp_enable
  id: parameter
  parameters:
    comment: 'HackRF front-end RF amp. 0=off, nonzero=on (+14 dB). CAUTION: enabling drops safe max RX input from +10 dBm to -5 dBm.'
    label: RF amp enable (DANGER - see comment)
    type: eng_float
    value: '0'
  states: {}
- name: gsm_bcch_ccch_demapper_0
  id: gsm_bcch_ccch_demapper
  parameters:
    timeslot_nr: '0'
  states: {}
- name: gsm_clock_offset_control_0
  id: gsm_clock_offset_control
  parameters:
    fc: fc_slider-shiftoff
    osr: osr
    samp_rate: samp_rate
  states: {}
- name: gsm_control_channels_decoder_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_control_channels_decoder_0_0
  id: gsm_control_channels_decoder
  parameters: {}
  states: {}
- name: gsm_decryption_0
  id: gsm_decryption
  parameters:
    a5_version: '1'
    k_c: '[]'
  states: {}
- name: gsm_input_0
  id: gsm_input
  parameters:
    fc: fc_slider-shiftoff
    ppm: ppm-int(ppm)
    samp_rate_in: samp_rate
  states: {}
- name: gsm_message_printer_1
  id: gsm_message_printer
  parameters:
    prepend_fnr: 'False'
    prepend_frame_count: 'False'
    prepend_string: '""'
    print_gsmtap_header: 'False'
  states: {}
- name: gsm_receiver_0
  id: gsm_receiver
  parameters:
    cell_allocation: '[arfcn.downlink2arfcn(fc)]'
    osr: osr
  states: {}
- name: gsm_sdcch8_demapper_0
  id: gsm_sdcch8_demapper
  parameters:
    timeslot_nr: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import gnuradio.gsm.arfcn as arfcn
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1500'
    port: serverport
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: collector
    mtu: '1500'
    port: collectorport
    type: UDP_CLIENT
  states: {}
- name: osr
  id: parameter
  parameters:
    label: OverSampling Ratio
    type: intx
    value: '4'
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: ppm
    short_id: p
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc_slider
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: args
    bb_gain0: vga_slider
    bw0: 250e3+abs(shiftoff)
    corr0: ppm_slider
    dc_offset_mode0: '2'
    freq0: fc_slider-shiftoff
    gain0: (14 if amp_enable else 0)
    gain_mode0: 'False'
    if_gain0: lna_slider
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: '2000000.052982'
  states: {}
- name: serverport
  id: parameter
  parameters:
    label: UDP server listening port
    type: str
    value: '4730'
  states: {}
- name: shiftoff
  id: parameter
  parameters:
    label: Frequency Shiftoff
    short_id: o
    type: eng_float
    value: 400e3
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: TX/RX
    bandwidth0: 250e3+abs(shiftoff)
    center_freq0: fc_slider-shiftoff
    dev_args: str(gsm.device.get_default_args(args))
    driver: uhd
    gain0: (14 if amp_enable else 0)
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_rotator_cc_0, '0', gsm_input_0, '0']
- [blocks_rotator_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [gsm_bcch_ccch_demapper_0, bursts, gsm_control_channels_decoder_0, bursts]
- [gsm_clock_offset_control_0, ctrl, gsm_input_0, ctrl_in]
- [gsm_control_channels_decoder_0, msgs, network_socket_pdu_1, pdus]
- [gsm_control_channels_decoder_0_0, msgs, network_socket_pdu_1, pdus]
- [gsm_decryption_0, bursts, gsm_control_channels_decoder_0_0, bursts]
- [gsm_input_0, '0', gsm_receiver_0, '0']
- [gsm_receiver_0, C0, gsm_bcch_ccch_demapper_0, bursts]
- [gsm_receiver_0, C0, gsm_sdcch8_demapper_0, bursts]
- [gsm_receiver_0, measurements, gsm_clock_offset_control_0, measurements]
- [gsm_sdcch8_demapper_0, bursts, gsm_decryption_0, bursts]
- [network_socket_pdu_0, pdus, gsm_message_printer_1, msgs]
- [rtlsdr_source_0, '0', blocks_rotator_cc_0, '0']
- [soapy_custom_source_0, '0', blocks_rotator_cc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-91-gb554eeab
